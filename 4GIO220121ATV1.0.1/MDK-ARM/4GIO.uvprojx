# Keil uVision project 4GIO.uvprojx, settings and files
target 4GIO (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 4GIOV1.0.1 +hex
  AfterMake: fromelf.exe --bin -o "%L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;         ../Drivers/STM32F1xx_HAL_Driver/Inc;         ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;         ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;         ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;         ../Middlewares/Third_Party/FreeRTOS/Source/include;         ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;         ../Drivers/CMSIS/Include;         ..\BSP\24CXX;         ..\BSP\MALLOC;         ..\Middlewares\Third_Party\cJSON;         ..\BSP\TM7705;         ..\AppProcess\logicaldata;         ..\AppProcess\uart1data;         ..\AppProcess\uart3data;         ..\AppProcess\uart4data;         ..\AppProcess\modbus;         ..\BSP\DTU;         ..\BSP\STMFLASH;         ..\IAP;         ..\SoftDrives\cSrting;         ..\SoftDrives\mqtt;         ..\mem;         ..\SoftDrives\ConfigModuleNoBlock
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x37800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/User
    ../Src/: main.c gpio.c freertos.c i2c.c iwdg.c rtc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_TIM.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ./: startup_stm32f103xe.s
    ..//Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group BSP
    ../BSP/24CXX/: 24cxx.c
    ../BSP/MALLOC/: malloc.c
    ../BSP/TM7705/: bsp_tm7705.c
    ../BSP/DTU/: dtu.c
    ../BSP/STMFLASH/: stmflash.c
  group CJSON
    ../Middlewares/Third_Party/cJSON/: cJSON.c
  group AppProcess
    ../AppProcess/logicaldata/: logicaldata.c
    ../AppProcess/uart1data/: uart1data.c
    ../AppProcess/uart3data/: uart3data.c
    ../AppProcess/uart4data/: uart4data.c
  group Modbus
    ../AppProcess/modbus/: modbus.c
  group IAP
    ../IAP/: iap.c
  group Cstring
    ../SoftDrives/cSrting/: cString.c
  group Mqtt
    ../SoftDrives/mqtt/: mqtt_msg.c mqtt.c
  group men
    ../mem/: BufferManage.c LoopList.c
  group ConfigModuleNoBlock
    ../SoftDrives/ConfigModuleNoBlock/: ConfigModuleNoBlock.c
software components: CMSIS:CORE 5.1.1
